# Keil uVision project opl1000_app_m3.uvprojx, settings and files
target OPL1000_APP (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: led_driver +hex
  AfterMake: .\opl1000_app_m3.bat $L !L @L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __noSIMULATOR__ __BLE__ __LE_HOST_USE_CMD__ __LWIP_TASK__ __WPA_SUPPLICANT__ __noHW_CRYPTO_ENGINE__ __WIFI_MAC_TASK__ __NL1000_An__ __PMP_ENABLE__ __PMP_REGION__ __HEAP_REGION__ noLWIP_DYNAMIC_DEBUG_ENABLE __AT_CMD_TASK__ __noRTL_SIMULATION__ __WIFI_AUTO_CONNECT__ OPL1000_APS ALI_BLE_WIFI_PROVISION
  c misc: --preinclude=sys_common.h
  c include: .\inc\APS\FreeRtos\Source\include;.\inc\APS\FreeRtos\Source\portable\Keil\ARM_CM3;.\inc\APS\driver\CMSIS\Include;.\inc\APS\driver\CMSIS\Device\opl1000\Include;.\inc\APS\driver\chip;.\inc\APS\driver\chip\opl1000\securityipdriver;.\inc\APS\driver\chip\opl1000\hal_auxadc;.\inc\APS\driver\chip\opl1000\hal_system;.\inc\APS\driver\chip\opl1000\hal_patch;.\inc\APS\driver\chip\opl1000\hal_uart;.\inc\APS\driver\chip\opl1000\hal_spi;.\inc\APS\driver\chip\opl1000\hal_vic;.\inc\APS\driver\chip\opl1000\hal_dbg_uart;.\inc\APS\driver\chip\opl1000\hal_wdt;.\inc\APS\driver\chip\opl1000\hal_dma;.\inc\APS\driver\chip\opl1000\hal_tmr;.\inc\APS\driver\chip\opl1000\hal_tick;.\inc\APS\driver\chip\opl1000\hal_pwm;.\inc\APS\driver\chip\opl1000\hal_i2c;.\inc\APS\project\opl1000\include;.\inc\APS\project\common;.\inc\APS\middleware\netlink;.\inc\APS\middleware\netlink\cli;.\inc\APS\middleware\netlink\msg;.\inc\APS\middleware\netlink\mw_fim;.\inc\APS\middleware\netlink\mw_ota;.\inc\APS\middleware\netlink\data_flow;.\inc\APS\middleware\netlink\wifi_controller_layer;.\inc\APS\middleware\netlink\ble_controller_layer\inc;.\inc\APS\middleware\netlink\le_stack;.\inc\APS\middleware\netlink\at;.\inc\APS\middleware\netlink\iperf\inc;.\inc\APS\middleware\netlink\controller_task;.\inc\APS\middleware\netlink\ps_task;.\inc\APS\middleware\netlink\diag_task;.\inc\APS\middleware\netlink\wifi_controller_layer\rom_if;.\inc\APS\middleware\netlink\wifi_mac;.\inc\APS\middleware\netlink\common\sys_api;.\inc\APS\middleware\netlink\common\sys_ctrl;.\inc\APS\apps\le_app\pts_app;.\inc\APS\apps\le_app\mtc_app;.\inc\APS\apps\le_app\cmd_app;.\inc\APS\middleware\third_party\wpa_supplicant-0.7.3\src\utils;.\inc\APS\middleware\third_party\wpa_supplicant-0.7.3\src\common;.\inc\APS\middleware\third_party\wpa_supplicant-0.7.3\wpa_supplicant;.\inc\APS\middleware\third_party\wpa_supplicant-0.7.3\src\eap_common;.\inc\APS\middleware\third_party\wpa_supplicant-0.7.3\src\eap_peer;.\inc\APS\middleware\third_party\wpa_supplicant-0.7.3\src\eapol_supp;.\inc\APS\middleware\third_party\wpa_supplicant-0.7.3\src\eapol_auth;.\inc\APS\middleware\third_party\wpa_supplicant-0.7.3\src\radius;.\inc\APS\middleware\third_party\wpa_supplicant-0.7.3\src\crypto;.\inc\APS\middleware\third_party\wpa_supplicant-0.7.3\src\drivers;.\inc\APS\middleware\third_party\wpa_supplicant-0.7.3\src\rsn_supp;.\inc\APS\middleware\third_party\wpa_supplicant-0.7.3\src\l2_packet;.\inc\APS\middleware\third_party\wpa_supplicant-0.7.3\src\ap;.\inc\APS\middleware\third_party\wpa_supplicant-0.7.3\src\wps;.\inc\APS\middleware\third_party\wpa_supplicant-0.7.3\wpa_supplicant\dbus;.\inc\APS\middleware\third_party\lwip-2.0.3\lwip\src\include;.\inc\APS\middleware\third_party\lwip-2.0.3\ports\freertos\include;.\inc\APS\middleware\third_party\lwip-2.0.3\ports\freertos\netif;.\inc\APS\middleware\third_party\lwip-2.0.3\ports\rom_if;.\inc\APS\middleware\third_party\lwip-2.0.3\;.\inc\APS\middleware\third_party\tinycrypt\include;.\inc\APS\middleware\third_party\mbedtls\include;.\inc\APS\project\opl1000\boot_sequence;.\inc\APS\project\opl1000\startup;.\inc\APS_PATCH\apps\le_app\include;.\inc\APS_PATCH\driver\chip\opl1000;.\inc\APS_PATCH\driver\chip\opl1000\hal_auxadc;.\inc\APS_PATCH\driver\chip\opl1000\hal_spi;.\inc\APS_PATCH\driver\chip\opl1000\hal_system;.\inc\APS_PATCH\driver\chip\opl1000\securityipdriver;.\inc\APS_PATCH\project\opl1000\startup;.\inc\APS_PATCH\project\opl1000\include;.\inc\APS_PATCH\middleware\netlink\data_flow;.\inc\APS_PATCH\middleware\netlink\msg;.\inc\APS_PATCH\middleware\netlink\mw_fim;.\inc\APS_PATCH\middleware\netlink\mw_ota;.\inc\APS_PATCH\middleware\netlink\ble_controller_layer\inc;.\inc\APS_PATCH\middleware\netlink\le_stack\patch;.\inc\APS_PATCH\middleware\netlink\le_stack\cmd_app;.\inc\APS_PATCH\middleware\netlink\le_stack\pts_app;.\inc\APS_PATCH\middleware\netlink\le_stack\mtc_app;.\inc\APS_PATCH\middleware\netlink\at;.\inc\APS_PATCH\middleware\netlink\diag_task;.\inc\APS_PATCH\middleware\netlink\wifi_controller_layer;.\inc\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\wpa_supplicant;.\inc\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\src\utils;.\inc\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\src\rsn_supp;.\inc\APS_PATCH\middleware\netlink\wifi_mac;.\inc\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\src\drivers;.\inc\APS_PATCH\middleware\netlink\wifi_controller_layer\rom_if;.\inc\APS_PATCH\middleware\third_party\lwip-2.0.3\ports\rom_if;.\inc\APS_PATCH\middleware\third_party\httpclient;.\inc\APS_PATCH\middleware\netlink\ps_task;.\inc\APS_PATCH\middleware\third_party\lwip-2.0.3\lwip\src\include;.\src;.\src\iot_data;.\src\breeze\api;.\src\breeze\hal\ble\include\mbedtls;.\src\breeze\hal\include;.\src\breeze\include;.\inc\APS_PATCH\middleware\third_party\aliyun_3.0.1\src\coap\server;.\inc\APS_PATCH\middleware\third_party\aliyun_3.0.1\src\coap\CoAPPacket;.\inc\APS_PATCH\middleware\third_party\aliyun_3.0.1\src\dev_bind;.\inc\APS_PATCH\middleware\third_party\aliyun_3.0.1\src\dev_bind\impl;.\inc\APS_PATCH\middleware\third_party\aliyun_3.0.1\src\dev_bind\impl\awss_reset;.\inc\APS_PATCH\middleware\third_party\aliyun_3.0.1\src\dev_bind\impl\os;.\inc\APS_PATCH\middleware\third_party\aliyun_3.0.1\src\dev_model;.\inc\APS_PATCH\middleware\third_party\aliyun_3.0.1\src\dev_model\client;.\inc\APS_PATCH\middleware\third_party\aliyun_3.0.1\src\dev_model\deprecated;.\inc\APS_PATCH\middleware\third_party\aliyun_3.0.1\src\dev_model\server;.\inc\APS_PATCH\middleware\third_party\aliyun_3.0.1\src\dev_sign;.\inc\APS_PATCH\middleware\third_party\aliyun_3.0.1\src\infra;.\inc\APS_PATCH\middleware\third_party\aliyun_3.0.1\src\kv\include;.\inc\APS_PATCH\middleware\third_party\aliyun_3.0.1\src\kv\include\aos;.\inc\APS_PATCH\middleware\third_party\aliyun_3.0.1\src\mqtt;.\inc\APS_PATCH\middleware\third_party\aliyun_3.0.1\src\mqtt\impl;.\inc\APS_PATCH\middleware\third_party\aliyun_3.0.1\src\wifi_provision;.\inc\APS_PATCH\middleware\third_party\aliyun_3.0.1\src\wifi_provision\zero_config;.\inc\APS_PATCH\middleware\third_party\aliyun_3.0.1\src\wifi_provision\frameworks;.\inc\APS_PATCH\middleware\third_party\aliyun_3.0.1\src\wifi_provision\frameworks\aplist;.\inc\APS_PATCH\middleware\third_party\aliyun_3.0.1\src\wifi_provision\frameworks\ieee80211;.\inc\APS_PATCH\middleware\third_party\aliyun_3.0.1\src\wifi_provision\frameworks\statics;.\inc\APS_PATCH\middleware\third_party\aliyun_3.0.1\src\wifi_provision\frameworks\utils;.\inc\APS_PATCH\middleware\third_party\aliyun_3.0.1\wrappers;.\inc\APS_PATCH\middleware\third_party\aliyun_3.0.1\src\dev_model\examples;.\inc\APS_PATCH\middleware\third_party\aliyun_3.0.1\src\coap;.\src\led_driver;.\src\breeze
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xc0000
  memory RVCT9: RAM 0x400000 size 0x50000
  scatter file: .\opl1000_app_m3.sct
  link misc: --datacompressor off --entry=__Patch_EntryPoint
  group src
    ./src/: main_patch.c blewifi_app.c blewifi_common.c blewifi_ctrl.c blewifi_data.c blewifi_server_app.c blewifi_server_app_gatt.c blewifi_ctrl_http_ota.c blewifi_http_ota.c blewifi_ble_api.c blewifi_wifi_api.c app_at_cmd.c mw_fim_default_group11_project.c mw_fim_default_group12_project.c mw_fim_default_group13_project.c mw_fim_default_group14_project.c
  group iot_data
    ./src/iot_data/: iot_data.c iot_rb_data.c ali_linkkitsdk_impl.c
  group object
    ./src/led_driver/: led_driver.lib
    ./lib/: opl1000_aliyun.lib opl1000_patch_m3.lib opl1000_sdk_m3.lib symdefs.o
  group ali_breeze_core
    ./src/breeze/core/: auth.c core.c extcmd.c sha256.c transport.c utils.c ali_hal_impl.c
  group ali_breeze_ble
    ./src/breeze/hal/ble/: aes.c aes_mbed.c breeze_hal_os.c breeze_hal_sec.c
